# Keil uVision project STWB_V1.2_PGA.uvprojx, settings and files
target STWB_V1.2_PGA (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F303CBTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.2.2
  cpu: IRAM(0x20000000-0x20007FFF) IRAM2(0x10000000-0x10001FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: STWB_V1_2_PGA +hex
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32F303xC,__TARGET_FPU_VFP
  c include: ../Inc;../Drivers/STM32F3xx_HAL_Driver/Inc;../Drivers/STM32F3xx_HAL_Driver/Inc/Legacy;../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/Any/Inc;../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/F3xx/Inc;../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Inc;../MCSDK_v5.4.4-Full/MotorControl/MCSDK/SystemDriveParams;..\BSP;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;..\STD_BSP;..\STD_BSP\STM32F30x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x10000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f303xc.s
  group Application/User
    ../Src/: main.c gpio.c adc.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c mc_math.c mc_interface.c stm32f30x_mc_it.c mc_parameters.c ui_task.c user_interface.c opamp.c tim.c usb_device.c usbd_conf.c usbd_desc.c usbd_cdc_if.c stm32f3xx_it.c stm32f3xx_hal_msp.c
  group Drivers/STM32F3xx_HAL_Driver
    ../Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_ll_usb.c stm32f3xx_hal_pcd.c stm32f3xx_hal_pcd_ex.c stm32f3xx_hal.c stm32f3xx_hal_rcc.c stm32f3xx_hal_rcc_ex.c stm32f3xx_hal_gpio.c stm32f3xx_hal_dma.c stm32f3xx_hal_cortex.c stm32f3xx_hal_pwr.c stm32f3xx_hal_pwr_ex.c stm32f3xx_hal_flash.c stm32f3xx_hal_flash_ex.c stm32f3xx_hal_i2c.c stm32f3xx_hal_i2c_ex.c stm32f3xx_hal_exti.c stm32f3xx_hal_adc.c stm32f3xx_hal_adc_ex.c stm32f3xx_hal_opamp.c stm32f3xx_hal_opamp_ex.c stm32f3xx_hal_tim.c stm32f3xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Src/: system_stm32f3xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c r_divider_bus_voltage_sensor.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c sto_pll_speed_pos_fdbk.c virtual_speed_sensor.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/MCLib/F3xx/Src/: r3_2_f30x_pwm_curr_fdbk.c
    ../MCSDK_v5.4.4-Full/MotorControl/MCSDK/UILibrary/Src/: ui_irq_handler.c
  group BSP
    ../BSP/: board.c led.c schedule.c control.c parameter.c filter.c crc.c communication.c
    ../STD_BSP/: bsp_spi.c bsp_can.c bsp_tle5012.c bsp_usart3.c bsp_softiic1.c bsp_at24cxx.c bsp_key.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group STM32F30x_StdPeriph_Driver
    ../STD_BSP/STM32F30x_StdPeriph_Driver/src/: stm32f30x_gpio.c stm32f30x_rcc.c stm32f30x_spi.c stm32f30x_misc.c stm32f30x_dma.c stm32f30x_can.c stm32f30x_usart.c
software components: CMSIS:CORE 5.5.0, CMSIS:DSP 1.9.0-dev
