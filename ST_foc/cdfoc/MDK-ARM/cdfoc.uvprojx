# Keil uVision project cdfoc.uvprojx, settings and files
target cdfoc (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431CBUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.1.4.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4")
  output: cdfoc +hex
  AfterMake: ..\MDK-ARM\Keil5_disp_size_bar_v0.4.exe
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: ARM_MATH_CM4,USE_HAL_DRIVER,STM32G431xx
  c include: ../Inc;                                         ../Drivers/STM32G4xx_HAL_Driver/Inc;                                         ../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;                                         ../MCSDK_v5.4.8-Full/MotorControl/MCSDK/MCLib/Any/Inc;                                         ../MCSDK_v5.4.8-Full/MotorControl/MCSDK/MCLib/G4xx/Inc;                                         ../MCSDK_v5.4.8-Full/MotorControl/MCSDK/UILibrary/Inc;                                         ../MCSDK_v5.4.8-Full/MotorControl/MCSDK/SystemDriveParams;                                         ../Drivers/CMSIS/Device/ST/STM32G4xx/Include;                                         ../Drivers/CMSIS/DSP/Include;                                         ..\app;                                         ..\bsp;                              ../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User
    ../Src/: main.c motorcontrol.c mc_api.c motor_control_protocol.c mc_config.c mc_tasks.c regular_conversion_manager.c mc_math.c mc_interface.c stm32g4xx_mc_it.c mc_parameters.c ui_task.c user_interface.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/CMSIS
    ../Src/: system_stm32g4xx.c
  group Middlewares/MotorControl
    ../MCSDK_v5.4.8-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c circle_limitation.c digital_output.c enc_align_ctrl.c encoder_speed_pos_fdbk.c motor_power_measurement.c ntc_temperature_sensor.c open_loop.c pid_regulator.c pqd_motor_power_measurement.c pwm_curr_fdbk.c pwm_common.c ramp_ext_mngr.c revup_ctrl.c speed_pos_fdbk.c speed_torq_ctrl.c state_machine.c virtual_bus_voltage_sensor.c virtual_speed_sensor.c
    ../MCSDK_v5.4.8-Full/MotorControl/MCSDK/MCLib/G4xx/Src/: r3_2_g4xx_pwm_curr_fdbk.c
    ../MCSDK_v5.4.8-Full/MotorControl/MCSDK/UILibrary/Src/: ui_irq_handler.c
  group Bsp
    ../bsp/: board.c schedule.c filter.c
  group App
    ../app/: hqfoc_app.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_cordic.c stm32g4xx_hal_spi.c stm32g4xx_hal_spi_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c
software components: CMSIS:CORE 4.3.0
